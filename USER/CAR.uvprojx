# Keil uVision project CAR.uvprojx, settings and files
target CAR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAR +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\RGBLED;..\HARDWARE\SPEAKER;..\HARDWARE\FAN;..\HARDWARE\ULTRASONIC;..\HARDWARE\MOTOR;..\HARDWARE\INFRARED;..\HARDWARE\4LF;..\HARDWARE\GRAY;..\HARDWARE\SERVO;..\HARDWARE\BIUETOOTH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c LEDBYPWM.c LEDBYPWM.h time.c time.h protocol.c protocol.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s core_cm3.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/usart/: usart.c usart.h
  group HARDWARE
    ../HARDWARE/RGBLED/: LED.c LED.h
    ../HARDWARE/FAN/: FAN.c FAN.h
    ../HARDWARE/SPEAKER/: SPEAKER.c SPEAKER.h
    ../HARDWARE/ULTRASONIC/: ULTRASONIC.c ULTRASONIC.h
    ../HARDWARE/MOTOR/: MOTOR.c MOTOR.h
    ../HARDWARE/INFRARED/: INFRARED.c INFRARED.h
    ../HARDWARE/4LF/: 4LF.c 4LF.h
    ../HARDWARE/GRAY/: GRAY.c GRAY.h
    ../HARDWARE/SERVO/: SERVO.c SERVO.h
    ../HARDWARE/BIUETOOTH/: BLUETOOTH.c BLUETOOTH.h
